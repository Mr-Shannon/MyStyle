# Keil uVision project GD32Control.uvprojx, settings and files
target RT-Thread (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: GD32F103RB GigaDevice
  pack: Keil.GD32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GD32Control
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GD32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\..\Applications;..\..\Drivers;..\..\Libraries\GD32F10x_Firmware_Library\Firmware\CMSIS;..\..\Libraries\GD32F10x_Firmware_Library\Firmware\Peripherals\inc;..\..\..\..\include;..\..\..\..\components\drivers\include;..\..\..\..\components\finsh;..\..\..\..\components\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Applications
    ../../Applications/: applications.c startup.c
  group Drivers
    ../../Drivers/: board.c led.c usart.c
  group GD32F10x_Firmware_Library
    ../../Libraries/GD32F10x_Firmware_Library/Firmware/: startup_gd32f10x_md.s
    ../../Libraries/GD32F10x_Firmware_Library/Firmware/CMSIS/: system_gd32f10x.c
    ../../Libraries/GD32F10x_Firmware_Library/Firmware/Peripherals/src/: gd32f10x_adc.c gd32f10x_bkp.c gd32f10x_can.c gd32f10x_crc.c gd32f10x_dac.c gd32f10x_dma.c gd32f10x_eth.c gd32f10x_exmc.c gd32f10x_exti.c gd32f10X_fmc.c gd32f10x_gpio.c gd32f10x_i2c.c gd32f10x_iwdg.c gd32f10x_mcudbg.c gd32f10x_misc.c gd32f10x_pwr.c gd32f10x_rcc.c gd32f10x_rtc.c gd32f10x_sdio.c gd32f10x_spi.c gd32f10x_timer.c gd32f10x_usart.c gd32f10x_wwdg.c
  group Kenrel
    ../../../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c object.c scheduler.c slab.c thread.c timer.c
  group Cortex-M3
    ../../../../libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
  group DeviceDrivers
    ../../../../components/drivers/src/: completion.c dataqueue.c
    ../../../../components/drivers/serial/: serial.c
  group Finsh
    ../../../../components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c msh.c msh_cmd.c msh_file.c shell.c symbol.c
