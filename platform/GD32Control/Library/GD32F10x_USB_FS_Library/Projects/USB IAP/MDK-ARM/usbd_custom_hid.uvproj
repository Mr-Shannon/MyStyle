# Keil uVision project usbd_custom_hid.uvproj, settings and files
target GD32103C_USB_IAP (ARM-ADS)
  device: GD32F103RE GigaDevice
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x08000000-0x0807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Custom_HID +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F10X_HD,USE_GD32F103C_EVAL
  c include: ..\inc;..\..\..\Libraries\CMSIS;..\..\..\Libraries\GD32F10x_StdPeriph_Driver\inc;..\..\..\Libraries\GD32_USB_Device_Driver\inc;..\..\..\Libraries\GD32_USB_Device_Library\IAP\inc;..\..\..\Libraries\GD32_USB_Device_Library\Core\inc;..\..\..\Utilities\GD32_EVAL\GD32103C_EVAL;D:\Keil_v5\ARM\Pack\ARM\CMSIS\4.2.0\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group App
    ../src/: main.c usbd_desc.c usbd_user.c usb_hwp.c gd32_it.c
  group USB_Class
    ../../../Libraries/GD32_USB_Device_Library/IAP/src/: usbd_flash_if.c usbd_iap_core.c usbd_iap_mal.c
  group USB_Drivers
    ../../../Libraries/GD32_USB_Device_Driver/src/: usb_buf.c usb_core.c usb_int.c
  group USB_Library
    ../../../Libraries/GD32_USB_Device_Library/Core/src/: usbd_core.c usbd_enum.c usbd_it.c usbd_pwr.c
  group GD32F10X
    ../../../Libraries/CMSIS/: core_cm3.c system_gd32f10x.c
    ../../../Libraries/StartUp/: startup_gd32f10x_hd.s startup_gd32f10x_md.s
  group GD32103B_EVAL
    ../../../Utilities/GD32_EVAL/GD32103B_EVAL/: gd32103b_eval.c
  group GD32103C_EVAL
    ../../../Utilities/GD32_EVAL/GD32103C_EVAL/: gd32103c_eval.c
  group GD32103E_EVAL
    ../../../Utilities/GD32_EVAL/GD32103E_EVAL/: gd32103e_eval.c
  group GD32F10x_StdPeriph_Driver
    ../../../Libraries/GD32F10x_StdPeriph_Driver/src/: gd32f10x_exti.c gd32f10X_fmc.c gd32f10x_gpio.c gd32f10x_misc.c gd32f10x_rcc.c gd32f10x_usart.c gd32f10x_dma.c gd32f10x_sdio.c gd32f10x_spi.c
target GD32103B_USB_IAP (ARM-ADS)
  device: GD32F10x GigaDevice
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Custom_HID +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F10X_MD,USE_GD32F103B_EVAL
  c include: ..\inc;..\..\..\Libraries\CMSIS;..\..\..\Libraries\GD32F10x_StdPeriph_Driver\inc;..\..\..\Libraries\GD32_USB_Device_Driver\inc;..\..\..\Libraries\GD32_USB_Device_Library\IAP\inc;..\..\..\Libraries\GD32_USB_Device_Library\Core\inc;..\..\..\Utilities\GD32_EVAL\GD32103B_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target GD32103E_USB_IAP (ARM-ADS)
  device: GD32F10x GigaDevice
  cpu: as above
  output: Custom_HID +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F10X_HD,USE_GD32F103E_EVAL
  c include: ..\inc;..\..\..\Libraries\CMSIS;..\..\..\Libraries\GD32F10x_StdPeriph_Driver\inc;..\..\..\Libraries\GD32_USB_Device_Driver\inc;..\..\..\Libraries\GD32_USB_Device_Library\IAP\inc;..\..\..\Libraries\GD32_USB_Device_Library\Core\inc;..\..\..\Utilities\GD32_EVAL\GD32103E_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
